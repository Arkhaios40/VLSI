v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -830 1190 1410 1190 {}
L 4 -830 1200 1410 1200 {}
L 4 -850 5490 1390 5490 {}
L 4 -850 5500 1390 5500 {}
L 4 -780 3360 1460 3360 {}
N 30 -540 30 -490 {
lab=I+-}
N -100 -540 30 -540 {
lab=I+-}
N -150 -460 -150 -440 { lab=GND}
N -150 -540 -150 -520 { lab=I+-}
N -150 -540 -90 -540 {
lab=I+-}
N 260 -470 380 -470 {
lab=#net1}
N 550 230 930 230 {
lab=#net2}
N 530 -90 530 -40 {
lab=#net3}
N 550 670 930 670 {
lab=#net4}
N 190 -90 530 -90 {
lab=#net3}
N -190 450 -190 470 { lab=GND}
N -190 370 -190 390 { lab=Q+-}
N -190 360 -190 370 {
lab=Q+-}
N -190 350 -190 360 {
lab=Q+-}
N -190 350 10 350 {
lab=Q+-}
N -170 780 10 780 {
lab=GND}
N -170 460 -170 780 {
lab=GND}
N -190 460 -170 460 {
lab=GND}
N 380 350 530 350 {
lab=#net5}
N 340 780 520 780 {
lab=#net6}
N -130 -450 -130 -90 {
lab=GND}
N -150 -450 -130 -450 {
lab=GND}
N -130 -90 -10 -90 {
lab=GND}
N 590 1330 610 1330 {
lab=VDD}
N 720 1330 740 1330 {
lab=VDD}
N 720 1280 720 1300 {
lab=VDD}
N 610 1280 610 1300 {
lab=VDD}
N 650 1330 680 1330 {
lab=#net7}
N 660 1330 660 1370 {
lab=#net7}
N 610 1370 660 1370 {
lab=#net7}
N 610 1360 610 1370 {
lab=#net7}
N 720 1540 760 1540 {
lab=#net8}
N 820 1540 830 1540 {
lab=VDD}
N 830 1540 830 1570 {
lab=VDD}
N 610 1370 610 1390 {
lab=#net7}
N 720 1360 720 1390 {
lab=#net9}
N 610 1280 720 1280 {
lab=VDD}
N 650 1420 680 1420 {
lab=#net7}
N 600 1420 610 1420 {
lab=VDD}
N 610 1450 610 1470 {
lab=#net7}
N 660 1420 660 1470 {
lab=#net7}
N 610 1470 660 1470 {
lab=#net7}
N 670 1330 670 1370 {
lab=#net7}
N 690 1490 690 1500 {
lab=#net7}
N 630 1540 660 1540 {
lab=#net10}
N 790 1540 790 1560 {
lab=VDD}
N 690 1540 690 1560 {
lab=VDD}
N 720 1420 740 1420 {
lab=VDD}
N 740 1280 740 1420 {
lab=VDD}
N 720 1280 740 1280 {
lab=VDD}
N 590 1420 600 1420 {
lab=VDD}
N 590 1280 590 1420 {
lab=VDD}
N 590 1280 610 1280 {
lab=VDD}
N 690 1560 830 1560 {
lab=VDD}
N 720 1450 960 1450 {
lab=#net11}
N -30 1370 -30 1420 {
lab=I2+-}
N -160 1370 -30 1370 {
lab=I2+-}
N 560 1470 610 1470 {
lab=#net7}
N -210 1450 -210 1470 { lab=GND}
N -210 1370 -210 1390 { lab=I2+-}
N -210 1370 -150 1370 {
lab=I2+-}
N 670 1370 670 1420 {
lab=#net7}
N 790 1490 790 1500 {
lab=#net7}
N 690 1490 790 1490 {
lab=#net7}
N 690 1460 690 1490 {
lab=#net7}
N 670 1460 690 1460 {
lab=#net7}
N 670 1420 670 1460 {
lab=#net7}
N 850 1930 850 1950 {
lab=VDD}
N 850 2060 850 2080 {
lab=VDD}
N 880 2060 900 2060 {
lab=VDD}
N 880 1950 900 1950 {
lab=VDD}
N 850 1990 850 2020 {
lab=#net12}
N 810 2000 850 2000 {
lab=#net12}
N 810 1950 810 2000 {
lab=#net12}
N 810 1950 820 1950 {
lab=#net12}
N 640 2060 640 2100 {
lab=#net13}
N 640 2160 640 2170 {
lab=VDD}
N 610 2170 640 2170 {
lab=VDD}
N 790 1950 810 1950 {
lab=#net12}
N 790 2060 820 2060 {
lab=#net14}
N 900 1950 900 2060 {
lab=VDD}
N 760 1990 760 2020 {
lab=#net12}
N 760 1940 760 1950 {
lab=VDD}
N 710 1950 730 1950 {
lab=#net12}
N 710 2000 760 2000 {
lab=#net12}
N 710 1950 710 2000 {
lab=#net12}
N 810 2010 850 2010 {
lab=#net12}
N 680 2030 690 2030 {
lab=#net12}
N 640 1970 640 2000 {
lab=#net15}
N 620 2130 640 2130 {
lab=VDD}
N 620 2030 640 2030 {
lab=VDD}
N 760 2060 760 2080 {
lab=VDD}
N 760 2080 900 2080 {
lab=VDD}
N 900 2060 900 2080 {
lab=VDD}
N 760 1930 760 1940 {
lab=VDD}
N 760 1930 900 1930 {
lab=VDD}
N 900 1930 900 1950 {
lab=VDD}
N 620 2030 620 2170 {
lab=VDD}
N 710 1900 710 1950 {
lab=#net12}
N 760 2010 810 2010 {
lab=#net12}
N 680 2130 690 2130 {
lab=#net12}
N 690 2030 690 2130 {
lab=#net12}
N 690 2030 720 2030 {
lab=#net12}
N 720 2010 720 2030 {
lab=#net12}
N 720 2010 760 2010 {
lab=#net12}
N 730 2060 730 2170 {
lab=#net16}
N 730 2170 1110 2170 {
lab=#net16}
N 710 1850 710 1900 {
lab=#net12}
N 850 2370 850 2390 {
lab=VDD}
N 850 2500 850 2520 {
lab=VDD}
N 880 2500 900 2500 {
lab=VDD}
N 880 2390 900 2390 {
lab=VDD}
N 850 2430 850 2460 {
lab=#net17}
N 810 2440 850 2440 {
lab=#net17}
N 810 2390 810 2440 {
lab=#net17}
N 810 2390 820 2390 {
lab=#net17}
N 640 2500 640 2540 {
lab=#net18}
N 640 2600 640 2610 {
lab=VDD}
N 610 2610 640 2610 {
lab=VDD}
N 790 2390 810 2390 {
lab=#net17}
N 790 2500 820 2500 {
lab=#net19}
N 900 2390 900 2500 {
lab=VDD}
N 760 2430 760 2460 {
lab=#net17}
N 760 2380 760 2390 {
lab=VDD}
N 710 2390 730 2390 {
lab=#net17}
N 710 2440 760 2440 {
lab=#net17}
N 710 2390 710 2440 {
lab=#net17}
N 810 2450 850 2450 {
lab=#net17}
N 680 2470 690 2470 {
lab=#net17}
N 640 2410 640 2440 {
lab=#net20}
N 620 2570 640 2570 {
lab=VDD}
N 620 2470 640 2470 {
lab=VDD}
N 760 2500 760 2520 {
lab=VDD}
N 760 2520 900 2520 {
lab=VDD}
N 900 2500 900 2520 {
lab=VDD}
N 760 2370 760 2380 {
lab=VDD}
N 760 2370 900 2370 {
lab=VDD}
N 900 2370 900 2390 {
lab=VDD}
N 620 2470 620 2610 {
lab=VDD}
N 710 2340 710 2390 {
lab=#net17}
N 760 2450 810 2450 {
lab=#net17}
N 680 2570 690 2570 {
lab=#net17}
N 690 2470 690 2570 {
lab=#net17}
N 690 2470 720 2470 {
lab=#net17}
N 720 2450 720 2470 {
lab=#net17}
N 720 2450 760 2450 {
lab=#net17}
N 730 2500 730 2610 {
lab=#net21}
N 730 2610 1110 2610 {
lab=#net21}
N 710 2290 710 2340 {
lab=#net17}
N 840 2800 840 2820 {
lab=VDD}
N 840 2930 840 2950 {
lab=VDD}
N 870 2930 890 2930 {
lab=VDD}
N 870 2820 890 2820 {
lab=VDD}
N 840 2860 840 2890 {
lab=#net22}
N 800 2870 840 2870 {
lab=#net22}
N 800 2820 800 2870 {
lab=#net22}
N 800 2820 810 2820 {
lab=#net22}
N 630 2930 630 2970 {
lab=#net23}
N 630 3030 630 3040 {
lab=VDD}
N 600 3040 630 3040 {
lab=VDD}
N 780 2820 800 2820 {
lab=#net22}
N 780 2930 810 2930 {
lab=#net24}
N 890 2820 890 2930 {
lab=VDD}
N 750 2860 750 2890 {
lab=#net22}
N 750 2810 750 2820 {
lab=VDD}
N 700 2820 720 2820 {
lab=#net22}
N 700 2870 750 2870 {
lab=#net22}
N 700 2820 700 2870 {
lab=#net22}
N 800 2880 840 2880 {
lab=#net22}
N 670 2900 680 2900 {
lab=#net22}
N 630 2840 630 2870 {
lab=#net25}
N 610 3000 630 3000 {
lab=VDD}
N 610 2900 630 2900 {
lab=VDD}
N 750 2930 750 2950 {
lab=VDD}
N 750 2950 890 2950 {
lab=VDD}
N 890 2930 890 2950 {
lab=VDD}
N 750 2800 750 2810 {
lab=VDD}
N 750 2800 890 2800 {
lab=VDD}
N 890 2800 890 2820 {
lab=VDD}
N 610 2900 610 3040 {
lab=VDD}
N 700 2770 700 2820 {
lab=#net22}
N 750 2880 800 2880 {
lab=#net22}
N 670 3000 680 3000 {
lab=#net22}
N 680 2900 680 3000 {
lab=#net22}
N 680 2900 710 2900 {
lab=#net22}
N 710 2880 710 2900 {
lab=#net22}
N 710 2880 750 2880 {
lab=#net22}
N 720 2930 720 3040 {
lab=#net26}
N 720 3040 1100 3040 {
lab=#net26}
N 700 2720 700 2770 {
lab=#net22}
N -250 2360 -250 2380 { lab=GND}
N -250 2280 -250 2300 { lab=Q2+-}
N -250 2270 -250 2280 {
lab=Q2+-}
N -250 2260 -250 2270 {
lab=Q2+-}
N -250 2260 -50 2260 {
lab=Q2+-}
N -230 2690 -50 2690 {
lab=GND}
N -230 2370 -230 2690 {
lab=GND}
N -250 2370 -230 2370 {
lab=GND}
N -190 1460 -190 1820 {
lab=GND}
N -210 1460 -190 1460 {
lab=GND}
N -190 1820 -70 1820 {
lab=GND}
N 290 -470 290 1440 {
lab=#net1}
N 270 -90 270 1810 {
lab=#net3}
N 130 1820 270 1820 {
lab=#net3}
N 260 370 260 2270 {
lab=#net5}
N 120 2270 260 2270 {
lab=#net5}
N 200 1440 290 1440 {
lab=#net1}
N 270 1810 270 1820 {
lab=#net3}
N 440 1470 570 1470 {
lab=#net7}
N 310 -190 310 1470 {
lab=#net7}
N 310 1470 440 1470 {
lab=#net7}
N 700 1720 710 1720 {
lab=#net12}
N 710 1720 710 1840 {
lab=#net12}
N 710 1840 710 1850 {
lab=#net12}
N 320 210 320 1720 {
lab=#net12}
N 320 2560 320 2700 {
lab=#net22}
N 320 2700 700 2700 {
lab=#net22}
N 700 2700 700 2720 {
lab=#net22}
N 340 2280 710 2280 {
lab=#net17}
N 710 2280 710 2290 {
lab=#net17}
N 330 650 330 2280 {
lab=#net17}
N 330 2280 340 2280 {
lab=#net17}
N 350 1080 350 2700 {
lab=#net22}
N 700 -490 760 -490 {
lab=#net27}
N 960 1450 1140 1450 {
lab=#net11}
N 760 -490 1000 -490 {
lab=#net27}
N 390 3690 410 3690 {
lab=VDD}
N 520 3690 540 3690 {
lab=VDD}
N 520 3640 520 3660 {
lab=VDD}
N 410 3640 410 3660 {
lab=VDD}
N 450 3690 480 3690 {
lab=#net28}
N 460 3690 460 3730 {
lab=#net28}
N 410 3730 460 3730 {
lab=#net28}
N 410 3720 410 3730 {
lab=#net28}
N 520 3900 560 3900 {
lab=#net29}
N 620 3900 630 3900 {
lab=VDD}
N 630 3900 630 3930 {
lab=VDD}
N 410 3730 410 3750 {
lab=#net28}
N 520 3720 520 3750 {
lab=#net30}
N 410 3640 520 3640 {
lab=VDD}
N 450 3780 480 3780 {
lab=#net28}
N 400 3780 410 3780 {
lab=VDD}
N 410 3810 410 3830 {
lab=#net28}
N 460 3780 460 3830 {
lab=#net28}
N 410 3830 460 3830 {
lab=#net28}
N 470 3690 470 3730 {
lab=#net28}
N 490 3850 490 3860 {
lab=#net28}
N 430 3900 460 3900 {
lab=#net31}
N 590 3900 590 3920 {
lab=VDD}
N 490 3900 490 3920 {
lab=VDD}
N 520 3780 540 3780 {
lab=VDD}
N 540 3640 540 3780 {
lab=VDD}
N 520 3640 540 3640 {
lab=VDD}
N 390 3780 400 3780 {
lab=VDD}
N 390 3640 390 3780 {
lab=VDD}
N 390 3640 410 3640 {
lab=VDD}
N 490 3920 630 3920 {
lab=VDD}
N 10 3760 10 3810 {
lab=I1+-}
N -120 3760 10 3760 {
lab=I1+-}
N 360 3830 410 3830 {
lab=#net28}
N -170 3840 -170 3860 { lab=GND}
N -170 3760 -170 3780 { lab=I1+-}
N -170 3760 -110 3760 {
lab=I1+-}
N 470 3730 470 3780 {
lab=#net28}
N 590 3850 590 3860 {
lab=#net28}
N 490 3850 590 3850 {
lab=#net28}
N 490 3820 490 3850 {
lab=#net28}
N 470 3820 490 3820 {
lab=#net28}
N 470 3780 470 3820 {
lab=#net28}
N 650 4290 650 4310 {
lab=VDD}
N 650 4420 650 4440 {
lab=VDD}
N 680 4420 700 4420 {
lab=VDD}
N 680 4310 700 4310 {
lab=VDD}
N 650 4350 650 4380 {
lab=#net32}
N 610 4360 650 4360 {
lab=#net32}
N 610 4310 610 4360 {
lab=#net32}
N 610 4310 620 4310 {
lab=#net32}
N 440 4420 440 4460 {
lab=#net33}
N 440 4520 440 4530 {
lab=VDD}
N 410 4530 440 4530 {
lab=VDD}
N 590 4310 610 4310 {
lab=#net32}
N 590 4420 620 4420 {
lab=#net34}
N 700 4310 700 4420 {
lab=VDD}
N 560 4350 560 4380 {
lab=#net32}
N 560 4300 560 4310 {
lab=VDD}
N 510 4310 530 4310 {
lab=#net32}
N 510 4360 560 4360 {
lab=#net32}
N 510 4310 510 4360 {
lab=#net32}
N 610 4370 650 4370 {
lab=#net32}
N 480 4390 490 4390 {
lab=#net32}
N 440 4330 440 4360 {
lab=#net35}
N 420 4490 440 4490 {
lab=VDD}
N 420 4390 440 4390 {
lab=VDD}
N 560 4420 560 4440 {
lab=VDD}
N 560 4440 700 4440 {
lab=VDD}
N 700 4420 700 4440 {
lab=VDD}
N 560 4290 560 4300 {
lab=VDD}
N 560 4290 700 4290 {
lab=VDD}
N 700 4290 700 4310 {
lab=VDD}
N 420 4390 420 4530 {
lab=VDD}
N 510 4260 510 4310 {
lab=#net32}
N 560 4370 610 4370 {
lab=#net32}
N 480 4490 490 4490 {
lab=#net32}
N 490 4390 490 4490 {
lab=#net32}
N 490 4390 520 4390 {
lab=#net32}
N 520 4370 520 4390 {
lab=#net32}
N 520 4370 560 4370 {
lab=#net32}
N 530 4420 530 4530 {
lab=#net2}
N 530 4530 910 4530 {
lab=#net2}
N 510 4210 510 4260 {
lab=#net32}
N 650 4730 650 4750 {
lab=VDD}
N 650 4860 650 4880 {
lab=VDD}
N 680 4860 700 4860 {
lab=VDD}
N 680 4750 700 4750 {
lab=VDD}
N 650 4790 650 4820 {
lab=#net36}
N 610 4800 650 4800 {
lab=#net36}
N 610 4750 610 4800 {
lab=#net36}
N 610 4750 620 4750 {
lab=#net36}
N 440 4860 440 4900 {
lab=#net37}
N 440 4960 440 4970 {
lab=VDD}
N 410 4970 440 4970 {
lab=VDD}
N 590 4750 610 4750 {
lab=#net36}
N 590 4860 620 4860 {
lab=#net38}
N 700 4750 700 4860 {
lab=VDD}
N 560 4790 560 4820 {
lab=#net36}
N 560 4740 560 4750 {
lab=VDD}
N 510 4750 530 4750 {
lab=#net36}
N 510 4800 560 4800 {
lab=#net36}
N 510 4750 510 4800 {
lab=#net36}
N 610 4810 650 4810 {
lab=#net36}
N 480 4830 490 4830 {
lab=#net36}
N 440 4770 440 4800 {
lab=#net39}
N 420 4930 440 4930 {
lab=VDD}
N 420 4830 440 4830 {
lab=VDD}
N 560 4860 560 4880 {
lab=VDD}
N 560 4880 700 4880 {
lab=VDD}
N 700 4860 700 4880 {
lab=VDD}
N 560 4730 560 4740 {
lab=VDD}
N 560 4730 700 4730 {
lab=VDD}
N 700 4730 700 4750 {
lab=VDD}
N 420 4830 420 4970 {
lab=VDD}
N 510 4700 510 4750 {
lab=#net36}
N 560 4810 610 4810 {
lab=#net36}
N 480 4930 490 4930 {
lab=#net36}
N 490 4830 490 4930 {
lab=#net36}
N 490 4830 520 4830 {
lab=#net36}
N 520 4810 520 4830 {
lab=#net36}
N 520 4810 560 4810 {
lab=#net36}
N 530 4860 530 4970 {
lab=#net4}
N 530 4970 910 4970 {
lab=#net4}
N 510 4650 510 4700 {
lab=#net36}
N 640 5160 640 5180 {
lab=VDD}
N 640 5290 640 5310 {
lab=VDD}
N 670 5290 690 5290 {
lab=VDD}
N 670 5180 690 5180 {
lab=VDD}
N 640 5220 640 5250 {
lab=#net40}
N 600 5230 640 5230 {
lab=#net40}
N 600 5180 600 5230 {
lab=#net40}
N 600 5180 610 5180 {
lab=#net40}
N 430 5290 430 5330 {
lab=#net41}
N 430 5390 430 5400 {
lab=VDD}
N 400 5400 430 5400 {
lab=VDD}
N 580 5180 600 5180 {
lab=#net40}
N 580 5290 610 5290 {
lab=#net42}
N 690 5180 690 5290 {
lab=VDD}
N 550 5220 550 5250 {
lab=#net40}
N 550 5170 550 5180 {
lab=VDD}
N 500 5180 520 5180 {
lab=#net40}
N 500 5230 550 5230 {
lab=#net40}
N 500 5180 500 5230 {
lab=#net40}
N 600 5240 640 5240 {
lab=#net40}
N 470 5260 480 5260 {
lab=#net40}
N 430 5200 430 5230 {
lab=#net43}
N 410 5360 430 5360 {
lab=VDD}
N 410 5260 430 5260 {
lab=VDD}
N 550 5290 550 5310 {
lab=VDD}
N 550 5310 690 5310 {
lab=VDD}
N 690 5290 690 5310 {
lab=VDD}
N 550 5160 550 5170 {
lab=VDD}
N 550 5160 690 5160 {
lab=VDD}
N 690 5160 690 5180 {
lab=VDD}
N 410 5260 410 5400 {
lab=VDD}
N 500 5130 500 5180 {
lab=#net40}
N 550 5240 600 5240 {
lab=#net40}
N 470 5360 480 5360 {
lab=#net40}
N 480 5260 480 5360 {
lab=#net40}
N 480 5260 510 5260 {
lab=#net40}
N 510 5240 510 5260 {
lab=#net40}
N 510 5240 550 5240 {
lab=#net40}
N 520 5290 520 5400 {
lab=#net44}
N 520 5400 900 5400 {
lab=#net44}
N 500 5080 500 5130 {
lab=#net40}
N 170 4210 510 4210 {
lab=#net32}
N -210 4750 -210 4770 { lab=GND}
N -210 4670 -210 4690 { lab=Q1+-}
N -210 4660 -210 4670 {
lab=Q1+-}
N -210 4650 -210 4660 {
lab=Q1+-}
N -210 4650 -10 4650 {
lab=Q1+-}
N -190 5080 -10 5080 {
lab=GND}
N -190 4760 -190 5080 {
lab=GND}
N -210 4760 -190 4760 {
lab=GND}
N 360 4650 510 4650 {
lab=#net36}
N 320 5080 500 5080 {
lab=#net40}
N -150 3850 -150 4210 {
lab=GND}
N -170 3850 -150 3850 {
lab=GND}
N -150 4210 -30 4210 {
lab=GND}
N 570 5630 590 5630 {
lab=VDD}
N 700 5630 720 5630 {
lab=VDD}
N 700 5580 700 5600 {
lab=VDD}
N 590 5580 590 5600 {
lab=VDD}
N 630 5630 660 5630 {
lab=#net45}
N 640 5630 640 5670 {
lab=#net45}
N 590 5670 640 5670 {
lab=#net45}
N 590 5660 590 5670 {
lab=#net45}
N 700 5840 740 5840 {
lab=#net46}
N 800 5840 810 5840 {
lab=VDD}
N 810 5840 810 5870 {
lab=VDD}
N 590 5670 590 5690 {
lab=#net45}
N 700 5660 700 5690 {
lab=#net47}
N 590 5580 700 5580 {
lab=VDD}
N 630 5720 660 5720 {
lab=#net45}
N 580 5720 590 5720 {
lab=VDD}
N 590 5750 590 5770 {
lab=#net45}
N 640 5720 640 5770 {
lab=#net45}
N 590 5770 640 5770 {
lab=#net45}
N 650 5630 650 5670 {
lab=#net45}
N 670 5790 670 5800 {
lab=#net45}
N 610 5840 640 5840 {
lab=#net15}
N 770 5840 770 5860 {
lab=VDD}
N 670 5840 670 5860 {
lab=VDD}
N 700 5720 720 5720 {
lab=VDD}
N 720 5580 720 5720 {
lab=VDD}
N 700 5580 720 5580 {
lab=VDD}
N 570 5720 580 5720 {
lab=VDD}
N 570 5580 570 5720 {
lab=VDD}
N 570 5580 590 5580 {
lab=VDD}
N 670 5860 810 5860 {
lab=VDD}
N 700 5750 940 5750 {
lab=#net11}
N -180 5670 -50 5670 {
lab=I3+-}
N 540 5770 590 5770 {
lab=#net45}
N -230 5750 -230 5770 { lab=GND}
N -230 5670 -230 5690 { lab=I3+-}
N -230 5670 -170 5670 {
lab=I3+-}
N 650 5670 650 5720 {
lab=#net45}
N 770 5790 770 5800 {
lab=#net45}
N 670 5790 770 5790 {
lab=#net45}
N 670 5760 670 5790 {
lab=#net45}
N 650 5760 670 5760 {
lab=#net45}
N 650 5720 650 5760 {
lab=#net45}
N 830 6230 830 6250 {
lab=VDD}
N 830 6360 830 6380 {
lab=VDD}
N 860 6360 880 6360 {
lab=VDD}
N 860 6250 880 6250 {
lab=VDD}
N 830 6290 830 6320 {
lab=#net48}
N 790 6300 830 6300 {
lab=#net48}
N 790 6250 790 6300 {
lab=#net48}
N 790 6250 800 6250 {
lab=#net48}
N 620 6360 620 6400 {
lab=#net49}
N 620 6460 620 6470 {
lab=VDD}
N 590 6470 620 6470 {
lab=VDD}
N 770 6250 790 6250 {
lab=#net48}
N 770 6360 800 6360 {
lab=#net50}
N 880 6250 880 6360 {
lab=VDD}
N 740 6290 740 6320 {
lab=#net48}
N 740 6240 740 6250 {
lab=VDD}
N 690 6250 710 6250 {
lab=#net48}
N 690 6300 740 6300 {
lab=#net48}
N 690 6250 690 6300 {
lab=#net48}
N 790 6310 830 6310 {
lab=#net48}
N 660 6330 670 6330 {
lab=#net48}
N 620 6270 620 6300 {
lab=#net10}
N 600 6430 620 6430 {
lab=VDD}
N 600 6330 620 6330 {
lab=VDD}
N 740 6360 740 6380 {
lab=VDD}
N 740 6380 880 6380 {
lab=VDD}
N 880 6360 880 6380 {
lab=VDD}
N 740 6230 740 6240 {
lab=VDD}
N 740 6230 880 6230 {
lab=VDD}
N 880 6230 880 6250 {
lab=VDD}
N 600 6330 600 6470 {
lab=VDD}
N 690 6200 690 6250 {
lab=#net48}
N 740 6310 790 6310 {
lab=#net48}
N 660 6430 670 6430 {
lab=#net48}
N 670 6330 670 6430 {
lab=#net48}
N 670 6330 700 6330 {
lab=#net48}
N 700 6310 700 6330 {
lab=#net48}
N 700 6310 740 6310 {
lab=#net48}
N 710 6360 710 6470 {
lab=#net16}
N 710 6470 1090 6470 {
lab=#net16}
N 690 6150 690 6200 {
lab=#net48}
N 830 6670 830 6690 {
lab=VDD}
N 830 6800 830 6820 {
lab=VDD}
N 860 6800 880 6800 {
lab=VDD}
N 860 6690 880 6690 {
lab=VDD}
N 830 6730 830 6760 {
lab=#net51}
N 790 6740 830 6740 {
lab=#net51}
N 790 6690 790 6740 {
lab=#net51}
N 790 6690 800 6690 {
lab=#net51}
N 620 6800 620 6840 {
lab=#net52}
N 620 6900 620 6910 {
lab=VDD}
N 590 6910 620 6910 {
lab=VDD}
N 770 6690 790 6690 {
lab=#net51}
N 770 6800 800 6800 {
lab=#net53}
N 880 6690 880 6800 {
lab=VDD}
N 740 6730 740 6760 {
lab=#net51}
N 740 6680 740 6690 {
lab=VDD}
N 690 6690 710 6690 {
lab=#net51}
N 690 6740 740 6740 {
lab=#net51}
N 690 6690 690 6740 {
lab=#net51}
N 790 6750 830 6750 {
lab=#net51}
N 660 6770 670 6770 {
lab=#net51}
N 620 6710 620 6740 {
lab=#net25}
N 600 6870 620 6870 {
lab=VDD}
N 600 6770 620 6770 {
lab=VDD}
N 740 6800 740 6820 {
lab=VDD}
N 740 6820 880 6820 {
lab=VDD}
N 880 6800 880 6820 {
lab=VDD}
N 740 6670 740 6680 {
lab=VDD}
N 740 6670 880 6670 {
lab=VDD}
N 880 6670 880 6690 {
lab=VDD}
N 600 6770 600 6910 {
lab=VDD}
N 690 6640 690 6690 {
lab=#net51}
N 740 6750 790 6750 {
lab=#net51}
N 660 6870 670 6870 {
lab=#net51}
N 670 6770 670 6870 {
lab=#net51}
N 670 6770 700 6770 {
lab=#net51}
N 700 6750 700 6770 {
lab=#net51}
N 700 6750 740 6750 {
lab=#net51}
N 710 6800 710 6910 {
lab=#net21}
N 710 6910 1090 6910 {
lab=#net21}
N 690 6590 690 6640 {
lab=#net51}
N 820 7100 820 7120 {
lab=VDD}
N 820 7230 820 7250 {
lab=VDD}
N 850 7230 870 7230 {
lab=VDD}
N 850 7120 870 7120 {
lab=VDD}
N 820 7160 820 7190 {
lab=#net54}
N 780 7170 820 7170 {
lab=#net54}
N 780 7120 780 7170 {
lab=#net54}
N 780 7120 790 7120 {
lab=#net54}
N 610 7230 610 7270 {
lab=#net55}
N 610 7330 610 7340 {
lab=VDD}
N 580 7340 610 7340 {
lab=VDD}
N 760 7120 780 7120 {
lab=#net54}
N 760 7230 790 7230 {
lab=#net56}
N 870 7120 870 7230 {
lab=VDD}
N 730 7160 730 7190 {
lab=#net54}
N 730 7110 730 7120 {
lab=VDD}
N 680 7120 700 7120 {
lab=#net54}
N 680 7170 730 7170 {
lab=#net54}
N 680 7120 680 7170 {
lab=#net54}
N 780 7180 820 7180 {
lab=#net54}
N 650 7200 660 7200 {
lab=#net54}
N 610 7140 610 7170 {
lab=#net20}
N 590 7300 610 7300 {
lab=VDD}
N 590 7200 610 7200 {
lab=VDD}
N 730 7230 730 7250 {
lab=VDD}
N 730 7250 870 7250 {
lab=VDD}
N 870 7230 870 7250 {
lab=VDD}
N 730 7100 730 7110 {
lab=VDD}
N 730 7100 870 7100 {
lab=VDD}
N 870 7100 870 7120 {
lab=VDD}
N 590 7200 590 7340 {
lab=VDD}
N 680 7070 680 7120 {
lab=#net54}
N 730 7180 780 7180 {
lab=#net54}
N 650 7300 660 7300 {
lab=#net54}
N 660 7200 660 7300 {
lab=#net54}
N 660 7200 690 7200 {
lab=#net54}
N 690 7180 690 7200 {
lab=#net54}
N 690 7180 730 7180 {
lab=#net54}
N 700 7230 700 7340 {
lab=#net26}
N 700 7340 1080 7340 {
lab=#net26}
N 680 7020 680 7070 {
lab=#net54}
N -270 6660 -270 6680 { lab=GND}
N -270 6580 -270 6600 { lab=Q3+-}
N -270 6570 -270 6580 {
lab=Q3+-}
N -270 6560 -270 6570 {
lab=Q3+-}
N -270 6560 -70 6560 {
lab=Q3+-}
N -250 6990 -70 6990 {
lab=GND}
N -250 6670 -250 6990 {
lab=GND}
N -270 6670 -250 6670 {
lab=GND}
N -210 5760 -210 6120 {
lab=GND}
N -230 5760 -210 5760 {
lab=GND}
N -210 6120 -90 6120 {
lab=GND}
N 250 4210 250 6110 {
lab=#net32}
N 110 6120 250 6120 {
lab=#net32}
N 240 4670 240 6570 {
lab=#net36}
N 100 6570 240 6570 {
lab=#net36}
N 230 5100 230 7010 {
lab=#net40}
N 250 6110 250 6120 {
lab=#net32}
N 420 5770 550 5770 {
lab=#net45}
N 290 4110 290 5770 {
lab=#net45}
N 290 5770 420 5770 {
lab=#net45}
N 680 6020 690 6020 {
lab=#net48}
N 690 6020 690 6140 {
lab=#net48}
N 690 6140 690 6150 {
lab=#net48}
N 300 4510 300 6020 {
lab=#net48}
N 300 6860 300 7000 {
lab=#net54}
N 300 7000 680 7000 {
lab=#net54}
N 680 7000 680 7020 {
lab=#net54}
N 320 6580 320 7290 {
lab=#net51}
N 320 6580 690 6580 {
lab=#net51}
N 690 6580 690 6590 {
lab=#net51}
N 310 4950 310 6580 {
lab=#net51}
N 310 6580 320 6580 {
lab=#net51}
N 330 5380 330 7000 {
lab=#net54}
N 520 3810 620 3810 {
lab=#net27}
N 680 3810 740 3810 {
lab=#net27}
N 940 5750 1120 5750 {
lab=#net11}
N 740 3810 980 3810 {
lab=#net27}
N 980 3810 1590 3810 {
lab=#net27}
N 910 4530 1600 4530 {
lab=#net2}
N 910 4970 1610 4970 {
lab=#net4}
N 900 5400 1620 5400 {
lab=#net44}
N 930 230 1600 230 {
lab=#net2}
N 930 670 1610 670 {
lab=#net4}
N 920 1100 1620 1100 {
lab=#net44}
N 1620 1100 1620 5400 {
lab=#net44}
N 1610 670 1610 4970 {
lab=#net4}
N 1600 230 1600 4530 {
lab=#net2}
N 1590 -490 1590 3810 {
lab=#net27}
N 1160 -490 1590 -490 {
lab=#net27}
N 1000 -490 1160 -490 {
lab=#net27}
N 450 -280 1510 -280 {
lab=#net35}
N 1620 1100 2205 1100 {
lab=#net44}
N 1610 670 2205 670 {
lab=#net4}
N 1600 230 2200 230 {
lab=#net2}
N 1590 -490 2220 -490 {
lab=#net27}
N 430 5100 430 5200 {
lab=#net43}
N 430 5100 1650 5100 {
lab=#net43}
N 440 4680 440 4770 {
lab=#net39}
N 440 4680 1660 4680 {
lab=#net39}
N 440 4230 440 4330 {
lab=#net35}
N 440 4230 1630 4230 {
lab=#net35}
N 430 3900 430 4000 {
lab=#net31}
N 430 4000 1640 4000 {
lab=#net31}
N 1510 -280 1630 -280 {
lab=#net35}
N 1630 -280 1630 4230 {
lab=#net35}
N 1500 -40 1640 -40 {
lab=#net31}
N 1640 -40 1640 4000 {
lab=#net31}
N 1490 370 1650 370 {
lab=#net43}
N 1650 375 1650 5100 {
lab=#net43}
N 1480 795 1660 795 {
lab=#net39}
N 1660 795 1660 4680 {
lab=#net39}
N 1640 4000 2540 4000 {
lab=#net31}
N 1630 4230 2535 4230 {
lab=#net35}
N 1660 4680 2530 4680 {
lab=#net39}
N 1650 5100 2595 5100 {
lab=#net43}
N 1120 5750 1120 5945 {
lab=#net11}
N 1120 5945 1670 5945 {
lab=#net11}
N 1090 6470 1680 6470 {
lab=#net16}
N 1090 6910 1690 6910 {
lab=#net21}
N 1080 7340 1700 7340 {
lab=#net26}
N 1670 1505 1670 5945 {
lab=#net11}
N 1670 1450 1670 1505 {
lab=#net11}
N 1140 1450 1670 1450 {
lab=#net11}
N 1110 2170 1680 2170 {
lab=#net16}
N 1680 2170 1680 6470 {
lab=#net16}
N 1690 2615 1690 6910 {
lab=#net21}
N 1690 2610 1690 2615 {
lab=#net21}
N 1110 2610 1690 2610 {
lab=#net21}
N 1100 3040 1695 3040 {
lab=#net26}
N 1695 3040 1700 3040 {
lab=#net26}
N 1700 3040 1700 7340 {
lab=#net26}
N 630 1540 630 1665 {
lab=#net10}
N 620 6120 620 6270 {
lab=#net10}
N 620 6120 1710 6120 {
lab=#net10}
N 1710 1635 1710 6120 {
lab=#net10}
N 610 5840 610 5995 {
lab=#net15}
N 610 5995 1720 5995 {
lab=#net15}
N 1720 1830 1720 5995 {
lab=#net15}
N 620 6555 620 6710 {
lab=#net25}
N 620 6555 1710 6555 {
lab=#net25}
N 610 7025 610 7140 {
lab=#net20}
N 610 7025 1735 7025 {
lab=#net20}
N 1705 6555 1765 6555 {
lab=#net25}
N 1735 2335 1735 7025 {
lab=#net20}
N 630 1665 1710 1665 {
lab=#net10}
N 640 1795 640 1970 {
lab=#net15}
N 640 1795 1720 1795 {
lab=#net15}
N 1720 1795 1720 1830 {
lab=#net15}
N 640 2320 640 2410 {
lab=#net20}
N 640 2320 1735 2320 {
lab=#net20}
N 1735 2320 1735 2335 {
lab=#net20}
N 1765 2735 1765 6555 {
lab=#net25}
N 630 2735 630 2840 {
lab=#net25}
N 630 2735 1765 2735 {
lab=#net25}
N 1730 7025 2410 7025 {
lab=#net20}
N 1760 6555 2410 6555 {
lab=#net25}
N 1710 6120 2395 6120 {
lab=#net10}
N 1720 5995 2400 5995 {
lab=#net15}
N 1700 3040 2570 3040 {
lab=#net26}
N 1690 2610 2580 2610 {
lab=#net21}
N 1680 2170 2575 2170 {
lab=#net16}
N 1670 1450 2240 1450 {
lab=#net11}
N 1650 370 1650 375 {
lab=#net43}
N 620 3810 675 3810 {
lab=#net27}
N 675 3810 680 3810 {
lab=#net27}
N 310 -460 310 -190 {
lab=#net7}
N 260 -490 260 -470 {
lab=#net1}
N 200 -490 260 -490 {
lab=#net1}
N 200 -460 310 -460 {
lab=#net7}
N -10 -90 10 -90 {
lab=GND}
N 180 -90 190 -90 {
lab=#net3}
N 180 -60 320 -60 {
lab=#net12}
N 320 -60 320 210 {
lab=#net12}
N 180 350 380 350 {
lab=#net5}
N 260 350 260 370 {
lab=#net5}
N 330 380 330 650 {
lab=#net17}
N 180 380 330 380 {
lab=#net17}
N 170 780 340 780 {
lab=#net6}
N 250 780 250 800 {
lab=#net6}
N 350 810 350 1080 {
lab=#net22}
N 170 810 350 810 {
lab=#net22}
N -30 1420 -30 1440 {
lab=I2+-}
N -30 1440 -20 1440 {
lab=I2+-}
N 150 1440 200 1440 {
lab=#net1}
N 320 1720 700 1720 {
lab=#net12}
N 150 1470 150 1490 {
lab=#net12}
N 150 1490 320 1490 {
lab=#net12}
N 100 1820 130 1820 {
lab=#net3}
N 100 1850 440 1850 {
lab=#net7}
N 440 1480 440 1850 {
lab=#net7}
N 440 1470 440 1480 {
lab=#net7}
N 120 2260 120 2270 {
lab=#net5}
N 120 2290 320 2290 {
lab=#net22}
N 320 2290 320 2560 {
lab=#net22}
N 120 2690 250 2690 {
lab=#net6}
N 120 2720 340 2720 {
lab=#net17}
N 250 800 250 2690 {
lab=#net6}
N 340 2280 340 2720 {
lab=#net17}
N 250 3830 360 3830 {
lab=#net28}
N 250 3810 250 3830 {
lab=#net28}
N 190 3810 250 3810 {
lab=#net28}
N 290 3840 290 4110 {
lab=#net45}
N 180 3840 290 3840 {
lab=#net45}
N 140 4210 170 4210 {
lab=#net32}
N 300 4240 300 4510 {
lab=#net48}
N 140 4240 300 4240 {
lab=#net48}
N 140 4650 360 4650 {
lab=#net36}
N 240 4650 240 4670 {
lab=#net36}
N 310 4680 310 4950 {
lab=#net51}
N 140 4680 310 4680 {
lab=#net51}
N 160 5080 320 5080 {
lab=#net40}
N 230 5080 230 5100 {
lab=#net40}
N 330 5110 330 5380 {
lab=#net54}
N 160 5110 330 5110 {
lab=#net54}
N 120 5670 270 5670 {
lab=#net28}
N 120 5700 300 5700 {
lab=#net48}
N 300 6020 680 6020 {
lab=#net48}
N 270 3830 270 5670 {
lab=#net28}
N 80 6120 110 6120 {
lab=#net32}
N 80 6150 420 6150 {
lab=#net45}
N 420 5770 420 6150 {
lab=#net45}
N 100 6560 100 6570 {
lab=#net36}
N 300 6590 300 6860 {
lab=#net54}
N 100 6590 300 6590 {
lab=#net54}
N 100 6990 230 6990 {
lab=#net40}
N 100 7020 320 7020 {
lab=#net51}
N 520 -470 700 -470 {
lab=#net27}
N 700 -490 700 -470 {
lab=#net27}
N 520 -450 520 -280 {
lab=#net35}
N 670 -40 1500 -40 {
lab=#net31}
N 670 -20 670 230 {
lab=#net2}
N 670 370 670 670 {
lab=#net4}
N 670 350 1500 350 {
lab=#net43}
N 1490 350 1490 370 {
lab=#net43}
N 660 800 660 1090 {
lab=#net44}
N 660 1090 660 1100 {
lab=#net44}
N 660 1100 920 1100 {
lab=#net44}
N 660 780 1480 780 {
lab=#net39}
N 1480 780 1480 800 {
lab=#net39}
C {devices/code.sym} 390 -1040 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {devices/vsource.sym} 180 -960 0 0 {name=VDD value=2}
C {devices/vdd.sym} 180 -990 0 0 {name=l4 lab=VDD}
C {devices/gnd.sym} 180 -930 0 0 {name=l5 lab=GND}
C {devices/code.sym} -78.75 -1044.375 0 0 {name=NGSPICE
only_toplevel=true
value="* this option enables mos model bin 
* selection based on W/NF instead of W
.control
op
*dc VDD 1 4 0.01
print all
save all
.endc
"
}
C {devices/vsource.sym} -150 -490 0 0 {name=V2 value="3"
*"pulse 0 1.8 0 1u 1u 10ms 20ms"}
C {devices/lab_pin.sym} -150 -540 0 0 {name=l16 sig_type=std_logic lab=I+-}
C {devices/gnd.sym} -150 -440 1 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -190 370 0 0 {name=l31 sig_type=std_logic lab=Q+-}
C {devices/gnd.sym} -190 470 1 0 {name=l32 lab=GND}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 700 1330 0 0 {name=M55
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 630 1330 0 1 {name=M56
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 790 1520 1 0 {name=M57
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 830 1570 2 0 {name=l38 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 630 1420 0 1 {name=M58
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 700 1420 0 0 {name=M59
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 690 1520 1 0 {name=M60
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -210 1370 0 0 {name=l40 sig_type=std_logic lab=I2+-}
C {devices/gnd.sym} -210 1470 1 0 {name=l41 lab=GND}
C {devices/vdd.sym} 680 1280 0 0 {name=l42 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 850 2040 1 0 {name=M61
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 850 1970 1 1 {name=M62
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 660 2130 2 0 {name=M63
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 610 2170 3 0 {name=l45 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 760 1970 1 1 {name=M64
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 760 2040 1 0 {name=M65
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 660 2030 2 0 {name=M66
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 900 2020 1 0 {name=l46 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 850 2480 1 0 {name=M85
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 850 2410 1 1 {name=M86
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 660 2570 2 0 {name=M87
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 610 2610 3 0 {name=l57 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 760 2410 1 1 {name=M88
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 760 2480 1 0 {name=M89
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 660 2470 2 0 {name=M90
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 900 2460 1 0 {name=l58 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 840 2910 1 0 {name=M91
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 840 2840 1 1 {name=M92
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 650 3000 2 0 {name=M93
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 600 3040 3 0 {name=l60 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 750 2840 1 1 {name=M94
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 750 2910 1 0 {name=M95
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 650 2900 2 0 {name=M96
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 890 2890 1 0 {name=l61 lab=VDD}
C {devices/lab_pin.sym} -250 2280 0 0 {name=l62 sig_type=std_logic lab=Q2+-}
C {devices/gnd.sym} -250 2380 1 0 {name=l63 lab=GND}
C {devices/vsource.sym} -190 420 0 0 {name=V1 value="0"
*pulse 0 1.8 0 1u 1u 10ms 20ms"}
C {devices/vsource.sym} -210 1420 0 0 {name=V3 value="3"
*pulse 0 1.8 0 1u 1u 10ms 20ms"}
C {devices/vsource.sym} -250 2330 0 0 {name=V4 value="2"
*pulse 0 1.8 0 1u 1u 10ms 20ms"}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 500 3690 0 0 {name=M103
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 430 3690 0 1 {name=M104
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 590 3880 1 0 {name=M105
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 630 3930 2 0 {name=l70 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 430 3780 0 1 {name=M106
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 500 3780 0 0 {name=M107
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 490 3880 1 0 {name=M108
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vsource.sym} -170 3810 0 0 {name=V5 value="3"
*pulse 0 1.8 0 1u 1u 10ms 20ms"}
C {devices/lab_pin.sym} -170 3760 0 0 {name=l72 sig_type=std_logic lab=I1+-}
C {devices/gnd.sym} -170 3860 1 0 {name=l73 lab=GND}
C {devices/vdd.sym} 480 3640 0 0 {name=l74 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 650 4400 1 0 {name=M109
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 650 4330 1 1 {name=M110
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 460 4490 2 0 {name=M111
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 410 4530 3 0 {name=l77 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 560 4330 1 1 {name=M112
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 560 4400 1 0 {name=M113
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 460 4390 2 0 {name=M114
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 700 4380 1 0 {name=l78 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 650 4840 1 0 {name=M133
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 650 4770 1 1 {name=M134
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 460 4930 2 0 {name=M135
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 410 4970 3 0 {name=l89 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 560 4770 1 1 {name=M136
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 560 4840 1 0 {name=M137
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 460 4830 2 0 {name=M138
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 700 4820 1 0 {name=l90 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 640 5270 1 0 {name=M139
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 640 5200 1 1 {name=M140
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 450 5360 2 0 {name=M141
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 400 5400 3 0 {name=l92 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 550 5200 1 1 {name=M142
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 550 5270 1 0 {name=M143
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 450 5260 2 0 {name=M144
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 690 5250 1 0 {name=l93 lab=VDD}
C {devices/lab_pin.sym} -210 4670 0 0 {name=l94 sig_type=std_logic lab=Q1+-}
C {devices/gnd.sym} -210 4770 1 0 {name=l95 lab=GND}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 680 5630 0 0 {name=M151
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 610 5630 0 1 {name=M152
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 770 5820 1 0 {name=M153
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 810 5870 2 0 {name=l102 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 610 5720 0 1 {name=M154
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 680 5720 0 0 {name=M155
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 670 5820 1 0 {name=M156
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -230 5670 0 0 {name=l104 sig_type=std_logic lab=I3+-}
C {devices/gnd.sym} -230 5770 1 0 {name=l105 lab=GND}
C {devices/vdd.sym} 660 5580 0 0 {name=l106 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 830 6340 1 0 {name=M157
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 830 6270 1 1 {name=M158
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 640 6430 2 0 {name=M159
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 590 6470 3 0 {name=l109 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 740 6270 1 1 {name=M160
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 740 6340 1 0 {name=M161
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 640 6330 2 0 {name=M162
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 880 6320 1 0 {name=l110 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 830 6780 1 0 {name=M181
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 830 6710 1 1 {name=M182
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 640 6870 2 0 {name=M183
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 590 6910 3 0 {name=l121 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 740 6710 1 1 {name=M184
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 740 6780 1 0 {name=M185
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 640 6770 2 0 {name=M186
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 880 6760 1 0 {name=l122 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 820 7210 1 0 {name=M187
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 820 7140 1 1 {name=M188
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 630 7300 2 0 {name=M189
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 580 7340 3 0 {name=l124 lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 730 7140 1 1 {name=M190
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 730 7210 1 0 {name=M191
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 630 7200 2 0 {name=M192
L=3
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/vdd.sym} 870 7190 1 0 {name=l125 lab=VDD}
C {devices/lab_pin.sym} -270 6580 0 0 {name=l126 sig_type=std_logic lab=Q3+-}
C {devices/gnd.sym} -270 6680 1 0 {name=l127 lab=GND}
C {devices/vsource.sym} -210 4720 0 0 {name=V7 value="2"
*pulse 0 1.8 0 1u 1u 10ms 20ms"}
C {devices/vsource.sym} -230 5720 0 0 {name=V8 value="0"
*pulse 0 1.8 0 1u 1u 10ms 20ms"}
C {devices/vsource.sym} -270 6630 0 0 {name=V9 value="0"
*pulse 0 1.8 0 1u 1u 10ms 20ms"}
C {devices/ammeter.sym} 2250 -490 3 0 {name=Vmeas2}
C {devices/ammeter.sym} 2230 230 3 0 {name=Vmeas4}
C {devices/ammeter.sym} 2235 670 3 0 {name=Vmeas5}
C {devices/ammeter.sym} 2235 1100 3 0 {name=Vmeas7}
C {devices/ammeter.sym} 2270 1450 3 0 {name=Vmeas8}
C {devices/ammeter.sym} 2600 2170 3 0 {name=Vmeas9}
C {devices/ammeter.sym} 2610 2610 3 0 {name=Vmeas10}
C {devices/ammeter.sym} 2600 3040 3 0 {name=Vmeas11}
C {devices/ammeter.sym} 2570 4000 3 0 {name=Vmeas12}
C {devices/ammeter.sym} 2565 4230 3 0 {name=Vmeas13}
C {devices/ammeter.sym} 2560 4680 3 0 {name=Vmeas14}
C {devices/ammeter.sym} 2625 5100 3 0 {name=Vmeas15}
C {devices/ammeter.sym} 2430 5995 3 0 {name=Vmeas16}
C {devices/ammeter.sym} 2425 6120 3 0 {name=Vmeas17}
C {devices/ammeter.sym} 2440 6555 3 0 {name=Vmeas18}
C {devices/ammeter.sym} 2440 7025 3 0 {name=Vmeas19}
C {devices/res.sym} 2470 7055 0 0 {name=R1
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2470 7085 0 0 {name=l1 lab=GND}
C {devices/res.sym} 2470 6585 0 0 {name=R2
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2470 6615 0 0 {name=l9 lab=GND}
C {devices/res.sym} 2455 6150 0 0 {name=R3
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2455 6180 0 0 {name=l11 lab=GND}
C {devices/res.sym} 2460 6025 0 0 {name=R4
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2460 6055 0 0 {name=l24 lab=GND}
C {devices/res.sym} 2655 5130 0 0 {name=R5
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2655 5160 0 0 {name=l27 lab=GND}
C {devices/res.sym} 2590 4710 0 0 {name=R6
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2590 4740 0 0 {name=l30 lab=GND}
C {devices/res.sym} 2595 4260 0 0 {name=R7
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2595 4290 0 0 {name=l33 lab=GND}
C {devices/res.sym} 2600 4030 0 0 {name=R8
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2600 4060 0 0 {name=l34 lab=GND}
C {devices/res.sym} 2630 3070 0 0 {name=R9
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2630 3100 0 0 {name=l37 lab=GND}
C {devices/res.sym} 2640 2640 0 0 {name=R10
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2640 2670 0 0 {name=l39 lab=GND}
C {devices/res.sym} 2630 2200 0 0 {name=R11
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2630 2230 0 0 {name=l44 lab=GND}
C {devices/res.sym} 2300 1480 0 0 {name=R12
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2300 1510 0 0 {name=l56 lab=GND}
C {devices/res.sym} 2265 1130 0 0 {name=R13
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2265 1160 0 0 {name=l59 lab=GND}
C {devices/res.sym} 2265 700 0 0 {name=R14
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2265 730 0 0 {name=l64 lab=GND}
C {devices/res.sym} 2260 260 0 0 {name=R15
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2260 290 0 0 {name=l65 lab=GND}
C {devices/res.sym} 2280 -460 0 0 {name=R16
value=10k
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2280 -430 0 0 {name=l66 lab=GND}
C {FinalProject/NmosStage1.sym} 50 -470 0 0 {name=x1}
C {FinalProject/NmosStage1.sym} 30 -70 0 0 {name=x2}
C {FinalProject/NmosStage1.sym} 30 370 0 0 {name=x3}
C {FinalProject/NmosStage1.sym} 20 800 0 0 {name=x4}
C {FinalProject/NmosStage1.sym} 0 1460 0 0 {name=x5}
C {FinalProject/NmosStage1.sym} -50 1840 0 0 {name=x6}
C {FinalProject/NmosStage1.sym} -30 2280 0 0 {name=x7}
C {FinalProject/NmosStage1.sym} -30 2710 0 0 {name=x8}
C {FinalProject/NmosStage1.sym} 30 3830 0 0 {name=x9}
C {FinalProject/NmosStage1.sym} -10 4230 0 0 {name=x10}
C {FinalProject/NmosStage1.sym} -10 4670 0 0 {name=x11}
C {FinalProject/NmosStage1.sym} 10 5100 0 0 {name=x12}
C {FinalProject/NmosStage1.sym} -30 5690 0 0 {name=x13}
C {FinalProject/NmosStage1.sym} -70 6140 0 0 {name=x14}
C {FinalProject/NmosStage1.sym} -50 6580 0 0 {name=x15}
C {FinalProject/NmosStage1.sym} -50 7010 0 0 {name=x16}
C {FinalProject/Stage2Pmos.sym} 370 -450 0 0 {name=x17}
C {FinalProject/Stage2Pmos.sym} 520 -20 0 0 {name=x18}
C {FinalProject/Stage2Pmos.sym} 520 370 0 0 {name=x19}
C {FinalProject/Stage2Pmos.sym} 510 800 0 0 {name=x20}
